# Keil uVision project F401_USB_Host_Main.uvprojx, settings and files
target F401_USB_Host_Main (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F401_USB_Host_Main +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./F401_USB_Host_Main/F401_USB_Host_Main.bin ./F401_USB_Host_Main/F401_USB_Host_Main.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,Device_Tag
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\F401_USB_Host_Main.sct
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c usb_host.c fatfs.c stm32f4xx_hal_msp.c usbh_conf.c usbh_diskio.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_core.c usbh_ioreq.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group App
    ../App/: app.c app_global.c
software components: CMSIS:CORE 4.3.0
